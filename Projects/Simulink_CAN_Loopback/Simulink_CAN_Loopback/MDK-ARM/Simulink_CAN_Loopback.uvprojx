# Keil uVision project Simulink_CAN_Loopback.uvprojx, settings and files
target Simulink_CAN_Loopback (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Simulink_CAN_Loopback +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32F405xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../../../Simulink_Timer/Simulink_Timer/Drivers/CMSIS/Core/Include; ../../../Simulink_Timer/Simulink_Timer/Drivers/CMSIS/DSP/Include; ../../../Simulink_Timer/Simulink_Timer/Simulink_Timer/Inc; ../../../../../../../MATLAB/R2018b/simulink/include; ../../../../../../../MATLAB/STM32/addSrc/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c can.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group MATLAB
    D:/MATLAB/STM32/addSrc/src/: getBuffPtr.c
    D:/文档/GitHub/2021-IFR-WinterTraining/Projects/Simulink_Timer/Simulink_Timer/Simulink_Timer/Src/: Simulink_Timer.c Simulink_Timer_TIM.c
software components: CMSIS:CORE 4.3.0
